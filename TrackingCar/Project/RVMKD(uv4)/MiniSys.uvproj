# Keil uVision project MiniSys.uvproj, settings and files
target MiniSys (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MiniSys +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\Delay;..\..\User\SysTick;..\..\User\Uart;..\..\User\Led;..\..\User\Pwm;..\..\User\Ldc1314;..\..\User\IIC;..\..\User\Motor;..\..\User\Tack;..\..\User\Control;..\..\User\pid;..\..\User\wheelSpeed;..\..\User\encoder;..\..\User\KEY;..\..\User\menu;..\..\User\OLED;..\..\User\Beep;..\..\User\speedMode;..\..\User\Esp8266;..\..\..\TrackingCar
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h
    ../../User/Delay/: delay.c
    ../../User/OLED/: oled.c
    ../../User/menu/: menu.c
    ../../User/speedMode/: speedMode.c
    ../../User/KEY/: key.c
    ../../User/Beep/: Beep.c
    ../../User/Led/: Led.c
    ../../User/Motor/: motor.c
    ../../User/SysTick/: SysTick.c
    ../../User/Control/: control.c
    ../../User/encoder/: encoder.c
    ../../User/IIC/: iic.c
    ../../User/Ldc1314/: ldc1314.c
    ../../User/pid/: pid.c
    ../../User/Pwm/: PwmOutput.c
    ../../User/Tack/: tack.c
  group DOC
    ../../Doc/: readme.txt
